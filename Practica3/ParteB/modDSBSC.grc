options:
  parameters:
    author: labcom
    category: '[ModulosEstudiantes]'
    copyright: UIS
    generate_options: hb
    id: Envolvente_Compleja_DSB_SC
    output_language: python
    title: Envolvente_Compleja_DSB_SC
  states: {}

blocks:
- name: Ac
  id: parameter
  parameters:
    label: Amplitud Portadora
    type: eng_float
    value: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Ac
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: m1(t)
    type: float
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: m2(t)
    type: float
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_float_to_complex_0, '0']
- [pad_source_1, '0', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
