options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: modAmpCuadrada
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Ampliud modulante
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '1'
  states: {state: disabled}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Ampliud portadora
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.1'
  states: {}
- name: GRX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del RX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Ka
    start: '0'
    step: '0.0001'
    stop: '4'
    value: '1'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: '50000000'
  states: {}
- name: fm1
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje coseno
    start: '1000'
    step: '1000'
    stop: '10000'
    value: '1000'
  states: {state: disabled}
- name: fm2
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje trianglar
    start: '1000'
    step: '1000'
    stop: '10000'
    value: '1000'
  states: {state: disabled}
- name: h1
  id: variable_qtgui_range
  parameters:
    label: 'hab1 '
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: h2
  id: variable_qtgui_range
  parameters:
    label: hab2
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(12500000/32)
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: frecuencia de muestreo
    start: '1000'
    step: '1000'
    stop: '300000'
    value: '200000'
  states: {state: disabled}
- name: CalculoPotencia_0
  id: CalculoPotencia
  parameters:
    I_vect: '1024'
  states: {state: disabled}
- name: CalculoPotencia_0_0
  id: CalculoPotencia
  parameters:
    I_vect: '1024'
  states: {state: disabled}
- name: Envolvente_Compleja_DSB_SC_0
  id: Envolvente_Compleja_DSB_SC
  parameters:
    Ac: Ac
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: fm1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: fm2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '44100'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: h1
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: h2
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Vídeos/LAB_COMU_B1B/Practica3/ParteA/despecha_rosalia.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Vídeos/LAB_COMU_B1B/Practica3/ParteB/session52_quevedobzrp.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Envolvente compleja"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: audio_rate
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: audio_rate
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: GRX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Envolvente_Compleja_DSB_SC_0, '0', qtgui_freq_sink_x_0, '0']
- [Envolvente_Compleja_DSB_SC_0, '0', qtgui_time_sink_x_0, '0']
- [Envolvente_Compleja_DSB_SC_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', CalculoPotencia_0, '0']
- [analog_sig_source_x_0, '0', Envolvente_Compleja_DSB_SC_0, '0']
- [analog_sig_source_x_0_0, '0', CalculoPotencia_0_0, '0']
- [analog_sig_source_x_0_0, '0', Envolvente_Compleja_DSB_SC_0, '1']
- [blocks_complex_to_float_0, '0', rational_resampler_xxx_0_1, '0']
- [blocks_complex_to_float_0, '1', rational_resampler_xxx_0_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '1']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_1, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', Envolvente_Compleja_DSB_SC_0, '0']
- [rational_resampler_xxx_0_0, '0', Envolvente_Compleja_DSB_SC_0, '1']
- [rational_resampler_xxx_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_1_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_float_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
